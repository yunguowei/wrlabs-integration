EXTRA_OEMAKE_class-native += 'CFLAGS="${CFLAGS} -Wformat"'
