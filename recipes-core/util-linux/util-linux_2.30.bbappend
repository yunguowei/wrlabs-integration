FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-agetty-fix-login-name-DEL-CTRL-U-issue.patch"
