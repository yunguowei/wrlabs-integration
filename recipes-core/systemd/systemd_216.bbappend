
PROVIDES += "libgudev"
