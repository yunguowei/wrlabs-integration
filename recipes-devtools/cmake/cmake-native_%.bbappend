# Avoid problem
#
# cmake: /build/tmp/sysroots/x86_64-linux/usr/bin/../lib/libcrypto.so.1.0.0: version `OPENSSL_1.0.0' not found (required by cmake)
# cmake: /build/tmp/sysroots/x86_64-linux/usr/bin/../lib/libssl.so.1.0.0: version `OPENSSL_1.0.1' not found (required by cmake)
# cmake: /build/tmp/sysroots/x86_64-linux/usr/bin/../lib/libssl.so.1.0.0: version `OPENSSL_1.0.0' not found (required by cmake)

DEPENDS += "openssl-native"