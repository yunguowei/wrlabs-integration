
RPROVIDES_${PN} = "git-bash-completion"
