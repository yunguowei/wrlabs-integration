# twisted-news not supported in python3
RDEPENDS_${PN}_remove = "${PN}-news"

