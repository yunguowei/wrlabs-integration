INSANE_SKIP_${PN}-python = "useless-rpaths"
