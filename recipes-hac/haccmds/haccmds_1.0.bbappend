RDEPENDS_${PN} += "perl"
