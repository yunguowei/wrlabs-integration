#fix the parabulding issue of:
#Cannot open src/xfce4-screenshooter.appdata.xml: No such file or directory

inherit autotools-brokensep
