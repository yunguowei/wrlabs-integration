DEPENDS += "libexif"
