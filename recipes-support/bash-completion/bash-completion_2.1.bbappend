FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-bash-completion-2.1-_init_completion-Handle-cword-0-.patch"
