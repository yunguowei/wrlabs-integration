# avoid the emacs cause the gpm configure failure
EXTRA_OECONF += "ac_cv_path_emacs=no"
