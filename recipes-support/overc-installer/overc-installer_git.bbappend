
SRC_URI = " \
    git://github.com/OverC/overc-installer.git;branch=2016-06-21 \
    file://git/COPYING \
"
