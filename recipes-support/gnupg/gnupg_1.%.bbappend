#
# Copyright (C) 2017 Wind River Systems, Inc.
#

DEPENDS_class-nativesdk = "zlib-native bzip2-replacement-native readline-native"
BBCLASSEXTEND += "nativesdk"
