#
# Copyright (C) 2017 Wind River Systems, Inc.
#

DEPENDS_class-nativesdk += "libxml2-nativesdk rpm-nativesdk"
BBCLASSEXTEND += "nativesdk"
