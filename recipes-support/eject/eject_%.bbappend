ALTERNATIVE_LINK_NAME[eject.1] = "${mandir}/man1/eject.1"
