RPROVIDES_${PN} = "adwaita-icon-theme"
