
# Fix QA check build failure for dev package while waiting for mainline merge

INSANE_SKIP_${PN}-dev += "dev-elf"
